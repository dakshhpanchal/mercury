Commit message: .

File: src/description/urdf/robot.urdf (robot description, URDF)
Before this commit: robot mercury_robot, 4 links, 3 joints
Links:
- removed link laser_link
- added link laser; visual cylinder length=0.05 radius=0.05
Joints:
- joint laser_joint: child laser_link -> laser
